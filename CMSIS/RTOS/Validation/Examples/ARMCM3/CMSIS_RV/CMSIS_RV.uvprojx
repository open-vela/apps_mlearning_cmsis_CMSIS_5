# Keil uVision project CMSIS_RV.uvprojx, settings and files
target Debug (6060000::V6.6::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: CMSIS-RV
  c flags: Optim=2 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Documents
    ./: Abstract.txt
  group Source
    ./: main.c
target CreateXML (6060000::V6.6::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: as above
  output: CMSIS-RV
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PRINT_XML_REPORT=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS RTOS Validation:Framework 1.0.0, CMSIS RTOS Validation:GenWait 1.0.0, CMSIS RTOS Validation:MailQueue 1.0.0, CMSIS RTOS Validation:MemoryPool 1.0.0, CMSIS RTOS Validation:MsgQueue 1.0.0, CMSIS RTOS Validation:Mutex 1.0.0, CMSIS RTOS Validation:Semaphore 1.0.0, CMSIS RTOS Validation:Signal 1.0.0, CMSIS RTOS Validation:Thread 1.0.0, CMSIS RTOS Validation:Timer 1.0.0, CMSIS RTOS Validation:WaitFunc 1.0.0, CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.0.1, Compiler:I/O:STDOUT 1.1.0
